# Keil uVision project Blcar.uvprojx, settings and files
target F103c8t6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blcar
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Prjc_Common\MAIN;..\..\Prjc_Common\Startup_config\core;..\..\Prjc_Common\Startup_config\device;..\..\Prjc_Common\Startup_config\device\startup;..\..\Prjc_Common\STM32F10x_StdPeriph_Driver\inc;..\..\Prjc_Common\Common;..\..\Prjc_Common\Board_2.1_Drive\inc;..\..\Prjc_Common\eMPL;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../../Prjc_Common/MAIN/: stm32f10x_it.c main.c
  group Startup_config
    ../../Prjc_Common/Startup_config/device/: system_stm32f10x.c
    ../../Prjc_Common/Startup_config/core/: core_cm3.c
    ../../Prjc_Common/Startup_config/device/startup/: startup_stm32f10x_md.s
  group Board_2.1_Drive
    ../../Prjc_Common/Board_2.1_Drive/src/: usart.c systick.c delay.c iic_oled.c adc.c iic_mpu.c mpu6050.c ultrasonic.c
  group Common
    ../../Prjc_Common/Common/: common.c
  group USER
    ../User/: control.c dmp_filter.c oled_show.c
  group STM32F1_FWLIB
    ../../Prjc_Common/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group IMU_eMPL
    ../../Prjc_Common/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c inv_mpu.h inv_mpu_dmp_motion_driver.h dmpmap.h dmpKey.h
  group Doc
    ../readme/: 1_io.txt 2_stm32.txt
